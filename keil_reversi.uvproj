# Keil uVision project keil_reversi.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c SWI_hal.s
  group Source Code
    ./: temporizador_drv.c temporizador_hal.c temporizador_drv.h temporizador_hal.h gpio_hal.h io_reserva.h fifo.c planificador.c planificador.h fifo.h main.c hello_world.c hello_world.h power.c power.h alarmas.c alarmas.h botones.h botones.c int_externas_hal.c juego.c int_externas_hal.h juego.h linea_serie_drv.c linea_serie_hal.c linea_serie_drv.h linea_serie_hal.h conversor.c conversor.h celda.h config_conecta_K.h entrada.h tablero.h tablero_test.h entrada.c tablero.c System_calls_hal.h Watchdog_hal.h Watchdog_hal.c conecta_K_2023.h conecta_K_2023.c conecta_K_buscar_alineamiento_arm.s conecta_K_hay_linea_arm_arm.s conecta_K_hay_linea_arm_c.s
